# Keil uVision project project.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\..\driver\CMSIS;..\..\driver\STM32F10x_StdPeriph_Driver;..\..\driver\STM32F10x_StdPeriph_Driver\inc;..\..\core\bsp;..\..\core\hardware;..\..\core\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Drivers/CMSIS
    ../../driver/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Drivers/STM32F10x_StdPeriph_Driver
    ../../driver/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../driver/STM32F10x_StdPeriph_Driver/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group App/Bsp
    ../../core/bsp/: bsp_utils.c bsp_delay.c bsp_timer.c bsp_math.c bsp_i2c.c bsp_i2c_hw.c bsp_rtc.c bsp_spi_hw.c
  group App/Hardware
    ../../core/hardware/: ad.c as5600.c counter.c dma.c encoder.c ic.c key.c led.c motor.c mpu6050.c oled.c oled_data.c pwm.c serial.c servo.c w25q64.c
  group App/Startup
    ../../driver/CMSIS/: startup_stm32f10x_ld.s
  group App/User
    ../../core/user/: main.c
